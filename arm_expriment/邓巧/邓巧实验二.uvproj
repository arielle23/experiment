# Keil uVision project 邓巧实验二.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: 邓巧实验二
  c flags: Optim=1
  memory RVCT9: RAM 0x40000000 size 0x1000
  group New Group
    ./: test2.s
